<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sdrSim</value></param>
<param><key>title</key><value>SDR Simulation</value></param>
<param><key>author</key><value>Daniel Franch</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>Channel Frequency Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>label</key><value>Channel Noise Voltage</value></param>
<param><key>value</key><value>0.0001</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>label</key><value>Channel Timing Offset</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0.999</value></param>
<param><key>stop</key><value>1.001</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>noise_voltage</key><value>noise_volt</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>epsilon</key><value>time_offset</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>100</value></param>
</block>
<block>
<key>bitErrorRate</key>
<param><key>id</key><value>bitErrorRate_0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>ber</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>label1</key><value>BER (in %)</value></param>
</block>
<block>
<key>sdrRX</key>
<param><key>id</key><value>sdrRX_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>sdrTX</key>
<param><key>id</key><value>sdrTX_0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<connection><source_block_id>sdrTX_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>sdrRX_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrTX_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>ber</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bitErrorRate_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrRX_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>bitErrorRate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>bitErrorRate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrTX_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
