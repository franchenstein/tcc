<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bitErrorRate</value></param>
<param><key>title</key><value>Bit Error Rate</value></param>
<param><key>author</key><value>Daniel Franch</value></param>
<param><key>description</key><value>Calculates the BER based on the known original message and the final received message.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>TCC-SDR</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>ber</value></param>
<param><key>label</key><value>ber</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>originalMessage</value></param>
<param><key>label</key><value>origMsg</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>bits_per_byte</value></param>
</block>
<block>
<key>blocks_xor_xx</key>
<param><key>id</key><value>blocks_xor_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>rxMsg</value></param>
<param><key>label</key><value>rxMsg</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.0/msgLength</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>decim</key><value>msgLength</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>bits_per_byte</value></param>
<param><key>value</key><value>8</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>./configs/sdrConfig.txt</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>key</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>msgLength</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>./configs/sdrConfig.txt</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>key</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rxMsg</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>originalMessage</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>ber</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_xor_xx_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
